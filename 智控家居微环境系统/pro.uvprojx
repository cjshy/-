# Keil uVision project pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\USER;.\DEVICE_LIB\inc;.\SYSTEM;.\SYSTEM\delay;.\SYSTEM\sys;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMISS
    ./CMSIS/: startup_stm32f40_41xxx.s
  group USER
    ./USER/: main.c stm32f4xx_it.c key.c led.c beep.c nvic.c systick.c time.c pwm.c usart.c dht11.c iic.c oled.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group HARDWARE
    ./HARDWARE/: spi.c spi.h adc.c wifi.c
  group SYSTEM
    ./SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group DEVICE_LIB
    ./DEVICE_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_spi.c
